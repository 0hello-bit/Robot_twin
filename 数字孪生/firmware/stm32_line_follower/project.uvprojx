# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h mono_time.c mono_time.h mono_time_core.c mono_time_core.h
  group Hardware
    ./Hardware/: PWM.c Motor.c Sensor.c mpu6050.c mpu6050_hardware_i2c_diag.c
  group User
    ./User/: main.c telemetry_batch.c telemetry_batch.h telemetry_delivery.c telemetry_delivery.h telemetry_rate.h twin_control_protocol.c twin_control_protocol.h ipd_parser.c ipd_parser.h esp_runtime_transport.c esp_runtime_transport.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h uart_ring.c uart_ring.h motor_register_diag.c motor_register_diag.h imu_diagnostic.h send_response_parser.c send_response_parser.h cipsend_transaction.c cipsend_transaction.h cipsend_tx.c cipsend_tx.h tx_frame_queue.c tx_frame_queue.h esp_tx_coordinator.c esp_tx_coordinator.h esp_transparent_session.c esp_transparent_session.h health_frame.h health_frame.c health_stats.h health_stats.c health_watchdog.h health_watchdog.c
